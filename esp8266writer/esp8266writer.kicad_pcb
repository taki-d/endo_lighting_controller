# Repository taki-d/endo_lighting_controller

File README.md:

# endo_lighting_controller
endo lighting controller board and firmware

## KiCad design esp8266writer/esp8266writer.kicad_pcb

Parts:
C1, C2: 4.7u; C_0603_1608Metric
C3: 1u; C_0603_1608Metric
C4: 1000p; C_0603_1608Metric
C5, C6: 10u; C_0805_2012Metric
D1, D2: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_C_Receptacle_USB2.0; 918-418K2023S40024
J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
Q1, Q2: BSS138; SOT-23
R1, R2: 4.7k; R_0603_1608Metric
R3: 24k; R_0603_1608Metric
R4: 47k; R_0603_1608Metric
R5, R8, R9: 10k; R_0603_1608Metric
R6, R7: 1k; R_0603_1608Metric
SW1, SW2: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: CP2104; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U2: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, C3.1, C6.1, J2.1, R5.2, R6.2, R7.2, R8.2, R9.2, U1.5 (VIO), U1.6 (VDD), U1.7 (REGIN), U2.2 (VO)
+5V: C5.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R3.2, U2.3 (VI)
/D+: J1.A6 (D+), J1.B6 (D+), U1.3 (D+)
/D-: J1.A7 (D-), J1.B7 (D-), U1.4 (D-)
/DTR: Q1.1 (G), Q2.2 (S), U1.23 (~DTR)
/ESP_RX: J2.3, U1.21 (TXD)
/ESP_TX: J2.2, U1.20 (RXD)
/IO0: J2.4, Q2.3 (D), R8.1, SW2.2
/RESET: C4.1, J2.5, Q1.3 (D), R9.1, SW1.2
/RTS: Q1.2 (S), Q2.1 (G), U1.19 (~RTS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.6, R1.1, R2.1, R4.1, SW1.1, SW2.1, U1.2 (GND), U1.25 (GND), U2.1 (GND)
unnamed: D1.2 (A), R6.1
unnamed: D1.1 (K), U1.14 (TXT/GPIO.0)
unnamed: D2.2 (A), R7.1
unnamed: D2.1 (K), U1.13 (RXT/GPIO.1)
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.B5 (CC2), R1.2
unnamed: R3.1, R4.2, U1.8 (VBUS)
unnamed: C1.1, U1.16 (VPP)
unnamed: R5.1, U1.9 (~RST)

Board: 2 copper layers, 50.0 x 50.0 mm, 29 parts (0 on the bottom side), 20 nets.

## KiCad design smartlight/smartlight.kicad_pcb

Parts:
C1: 100n; C_0603_1608Metric
C2: 1u; C_0603_1608Metric
FID1, FID2, FID3, FID4: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: mousebite; mousebites_1mm
J1: Conn_01x06; PinHeader_1x06_P1.27mm_Vertical
J2: Conn_01x05; ENDO_CONTROLLER
R1, R2: 100; R_0402_1005Metric
R3, R4, R5, R6, R7: 10k; R_0402_1005Metric
U1: ESP-12F; ESP-12E

Connections:
+3V3: C1.1, C2.1, J1.1, J2.2, R3.1, R4.1, R5.1, R7.1, U1.8 (VCC)
ESP12F_RX: J1.3, U1.21 (GPIO3/RXD)
ESP12F_TX: J1.2, U1.22 (GPIO1/TXD)
GND: C1.2, C2.2, J1.6, J2.3, R6.2, U1.15 (GND)
IO0: J1.4, R7.2, U1.18 (GPIO0)
unnamed: J2.4, R1.2
unnamed: J2.5, R2.2
unnamed: R4.2, U1.3 (EN)
unnamed: R5.2, U1.17 (GPIO2)
unnamed: R6.1, U1.16 (GPIO15)
ON/OFF: R2.1, U1.6 (GPIO12)
PWM: R1.1, U1.5 (GPIO14)
RESET: J1.5, R3.2, U1.1 (~RST)

Notes on the sheet:
書き込み治具用コネクタ

Board: 2 copper layers, 43.0 x 36.0 mm, 20 parts (0 on the bottom side), 13 nets.

## Commit log

2024-05-24 add all
2024-05-24 add library
2024-05-29 before swapping pin snapshot
2024-05-29 コントローラー管制
2024-06-11 [add] esphome.yaml
2024-06-11 [fix] id
2024-06-11 [fix] any
2024-06-14 [add] iroriro
2024-06-14 [add] statusLed
2024-06-14 [fix] default_transition_length
2024-06-14 [fix] include
2024-06-14 [fix] includes
2024-07-15 [add] install page
2024-07-15 Initial gh-pages commit
2024-07-15 Deploying to gh-pages from @ taki-d/endo_lighting_controller@789f66ac78d68b78fe6673a0a499ce4820649aa2 🚀
